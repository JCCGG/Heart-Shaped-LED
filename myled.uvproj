# Keil uVision project myled.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: myled +hex
  c flags: Optimize=8 SizeSpeed=1
  group myled
    ./users/: main.c
